FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://remove-gpio.patch"
